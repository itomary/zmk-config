## config/boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

config ZMK_KEYBOARD_NAME
    default "Macropad"

config ZMK_HID_CONSUMER_REPORT_SIZE
    default 6

endif
```
